# Keil uVision project light_monitor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: light_monitor +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 main.c STC15Fxxxx.H include.h
  group app
    ./: app_uart.c app_led.c app_adcSensor.c
